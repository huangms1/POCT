# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Poct_app
  AfterMake: fromelf --bin -o ../OBJ/@L.bin ../OBJ/@L.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\IIC;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MALLOC;..\HARDWARE\I2C_EEPROM;..\HARDWARE\Ethernet\Internet;..\HARDWARE\Ethernet\W5500;..\HARDWARE\TimBase;..\HARDWARE\adc;..\HARDWARE\PWM;..\HARDWARE\PID;..\HARDWARE\motor;.\APP;..\PROTOCOL\include;..\PUBLIC\include;..\STRUCTURE\include;..\APP_OBJECTS\include;..\TASK\include;..\HARDWARE\iap;..\INSTRUMENTS\include;..\INSTRUMENTS\source;..\MEM\include;..\HARDWARE\PAC9535;..\TIMER;..\HARDWARE\laser;..\HARDWARE\UltraSound
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20001000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ./APP/: poct_process.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/I2C_EEPROM/: bsp_i2c_ee.c bsp_i2c_gpio.c
    ../HARDWARE/Ethernet/Internet/: dhcp.c tcp_handler.h tcp_handler.c
    ../HARDWARE/Ethernet/W5500/: socket.c w5500.c w5500_conf.c utility.c
    ../HARDWARE/TimBase/: bsp_TiMbase.c
    ../HARDWARE/adc/: bsp_adc.c ADS8688.c ADS8688_conf.h
    ../HARDWARE/PWM/: bsp_pwm_conf.c
    ../HARDWARE/PID/: bsp_pid.c fuzzypid.c fuzzypid.h
    ../HARDWARE/motor/: bsp_motor_conf.c bsp_motor.c
    ../HARDWARE/iap/: iap.c iap.h
    ../HARDWARE/PAC9535/: DIV_Control.c DIV_Control.h pac9535.c pac9535.h
    ../HARDWARE/laser/: laser.c laser.h
    ../HARDWARE/UltraSound/: UltraSound.c UltraSound.h
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group MALLOC
    ../MALLOC/: malloc.c
  group PROTOCOL
    ../PROTOCOL/include/: Interpreter.h Msg.h StateMachine.h AppMsgDefine.h Reply.h
    ../PROTOCOL/source/: Interpreter.c Msg.c StateMachine.c Reply.c
  group PUBLIC
    ../PUBLIC/include/: PublicDefine.h includes.h
  group STRUCTURE
    ../STRUCTURE/source/: ExpiredTimer.c ZList.c ZQueue.c ZRing.c ZStr2StrMap.c
    ../STRUCTURE/include/: ExpiredTimer.h ZList.h ZQueue.h ZRing.h ZStr2StrMap.h
  group TASK
    ../TASK/include/: NormalExeTask.h RoutineTask.h SerialTask.h SocketTask.h StartTask.h UrgentExeTask.h LogTask.h UserAppRunTask.h IAPTask.h VibrateTask.h
    ../TASK/source/: NormalExeTask.c RoutineTask.c SerialTask.c SocketTask.c StartTask.c UrgentExeTask.c LogTask.c TempControlTask.c UserAppRunTask.c IAPTask.c VibrateTask.c
  group APP_OBJECTS
    ../APP_OBJECTS/include/: Endpoint.h Me.h RoutineManager.h Bridge.h CommBoardExe.h MainBoardExe.h TempBoardExe.h
    ../APP_OBJECTS/source/: Endpoint.c Me.c RoutineManager.c Bridge.c CommBoardExe.c MainBoardExe.c TempBoardExe.c
  group INSTRUMENTS
    ../INSTRUMENTS/include/: InstrumentInclude.h POCT_ANM_H1L4_A.h POCT_ANM_H3L5_A.h POCT_HMN_H5L5_A.h POCT_HMN_H2L8_A.h
    ../INSTRUMENTS/source/: POCT_ANM_H1L4_A.c POCT_ANM_H3L5_A.c POCT_HMN_H5L5_A.c POCT_HMN_H2L8_A.c
  group MEM
    ../MEM/include/: ZMem.h
    ../MEM/source/: ZMem.c
  group TIMER
    ../TIMER/: mytimer.c mytimer.h
  group README
    ../: readme.txt
